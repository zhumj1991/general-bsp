# Keil uVision project project.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\stm32f4xx;..\..\..\..\workspace\demo;..\..\..\..\system\src\uCOS-III\uC-CPU;..\..\..\..\system\src\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\system\src\uCOS-III\uC-LIB;..\..\..\..\system\src\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\system\src\uCOS-III\uCOS-III\Ports;..\..\..\..\system\src\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\system\src\uCOS-III\uCOS-III\Source;..\..\..\..\system\src\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\system\src\uCOS-III;..\..\..\..\cmd\include;..\..\..\..\gb\inc;..\..\..\..\gb\inc\bsp;..\..\..\..\gb\inc\dev;..\..\..\..\gb\src\dev;..\..\..\..\gb\inc\driver;..\..\..\..\gb\inc\driver\arch\st\stm32f4xx;..\..\..\..\gb\src\driver\arch\st\stm32f4xx\firmware\inc;..\..\..\..\lwip;..\..\..\..\lwip\src\include;..\..\..\..\lwip\src\include\ipv4;..\..\..\..\lwip\src\include\netif;..\..\..\..\lwip\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  link misc: --no_remove
  group config
    ./: startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c ucos-st.c app_cfg.h stm32f4xx_it.c
    ../../../../system/src/uCOS-III/: os_cfg.h os_cfg_app.h
  group workspace
    ../../../../workspace/demo/: main.c task.h diag_task.c eth_task.c
    ../../../../gb/: general bsp.txt
  group cmd
    ../../../../cmd/: console.c
    ../../../../cmd/commom/: command.c cmd_driver.c cmd_mem.c cmd_sf.c cmd_nvedit.c cmd_os.c env_common.c
  group gb/arch
    ../../../../gb/src/driver/arch/st/stm32f4xx/firmware/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group gb/bsp
    ../../../../gb/src/bsp/: gb_bsp.c
    ../../../../gb/inc/: gb_config.h
  group gb/dev
    ../../../../gb/src/dev/: led.c spi_flash.c dm9000x.c
  group gb/driver
    ../../../../gb/src/driver/: gb_driver.c
    ../../../../gb/src/driver/arch/st/stm32f4xx/: gpio.c rcc.c uart.c spi.c fsmc_sram.c interrupt.c
  group gb/rtos
    ../../../../gb/src/rtos/arch/ucos/: gb_malloc.c gb_queue.c gb_sem.c gb_thread.c gb_time.c gb_system.c
  group gb/source
    ../../../../gb/src/: gb_fifo.c
  group system/uc/cpu
    ../../../../system/src/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../system/src/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group system/uc/lib
    ../../../../system/src/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../system/src/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group system/uc/source
    ../../../../system/src/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group sysytem/uc/port
    ../../../../system/src/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
